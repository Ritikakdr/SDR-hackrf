options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '3200000.000000'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: 315e6
    fftsize: '32768'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: 315E6
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [soapy_rtlsdr_source_0, '0', qtgui_sink_x_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
